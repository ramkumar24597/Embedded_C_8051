# Keil uVision project RGB led c.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: RGB led c +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: RGB led PROG.c
